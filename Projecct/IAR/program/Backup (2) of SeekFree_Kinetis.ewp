# IAR project Backup (2) of SeekFree_Kinetis.ewp, settings and files
configuration MK66FX_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\FatFs; ..\..\..\Libraries\FatFs\option
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SeekFree_Kinetis.srec
  ILINK.IlinkOutputFile: SeekFree_Kinetis.out
  ILINK.IlinkIcfFile: linker\MK66xX1M_18.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group drives/inc
    ../../../Libraries/drives/inc/: common.h misc.h MK60_adc.h MK60_cmt.h MK60_dac.h MK60_dma.h MK60_flash.h MK60_ftm.h MK60_gpio.h MK60_i2c.h MK60_lptmr.h MK60_pit.h MK60_port.h MK60_port_cfg.h MK60_rtc.h MK60_sdhc.h MK60_spi.h MK60_systick.h MK60_uart.h MK60_wdog.h
  group fatfs
    ../../../Libraries/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h
  group fatfs/src
    ../../../Libraries/drives/src/: common.c misc.c MK60_adc.c MK60_cmt.c MK60_dac.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_pit.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_systick.c MK60_uart.c MK60_wdog.c
  group seekfree
    ../../USER/src/: font.c key.c printf.c
    ../../USER/inc/: font.h key.h printf.h
    ../../../Libraries/FatFs/: integer.h
    ../../../Libraries/seekfree/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_28LCD.c SEEKFREE_28LCD.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK66F18.s
    ../../../Libraries/startup/DeviceSupport/: system_MK66.c
  group user_c
    ../../USER/src/: isr.c main.c
    ../../../Libraries/: version.txt
  group user_c/Angle
    ../../USER/src/: fastmath.c I2C.c icm20602.c jiaodu.c Kalman.c matrix.c
    ../../USER/inc/: fastmath.h I2C.h icm20602.h jiaodu.h Kalman.h matrix.h
  group user_c/Back
    ../../USER/src/: Turn_Back.c
    ../../USER/inc/: Turn_Back.h
  group user_c/Camera
    ../../USER/src/: handle.c Otsumethod.c
    ../../USER/inc/: handle.h Otsumethod.h
  group user_c/Control__CAR___PIT
    ../../USER/src/: car.c Control.c pit.c
    ../../USER/inc/: car.h Control.h pit.h
  group user_c/DATA____FLASH
    ../../USER/src/: DATA.c flash.c
    ../../USER/inc/: DATA.h flash.h
  group user_c/Direction
    ../../USER/src/: ElectADC.c Filter.c
    ../../USER/inc/: ElectADC.h Filter.h
  group user_c/Motor
    ../../USER/src/: motor.c
    ../../USER/inc/: motor.h
  group user_c/PID
    ../../USER/src/: pid.c
    ../../USER/inc/: pid.h
  group user_h
    ../../../Libraries/drives/inc/: headfile.h
    ../../USER/inc/: isr.h
